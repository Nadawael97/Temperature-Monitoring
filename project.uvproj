# Keil uVision project project.uvproj, settings and files
target project (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: project
  AfterMake: fromelf --bin --output .\rvmdk\project.bin .\rvmdk\project.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1
  c misc: --c99
  c include: ..\..;D:\MC-Fall\LCD_Project
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: project.sct
  link misc: --entry Reset_Handler
  group Source
    ./: project.c startup_rvmdk.S
    ./utils/: uartstdio.c
    D:/MC-Fall/LCD_Project/: Delay.c initialization.c
  group Libraries
    ../../driverlib/rvmdk/: driverlib.lib
    ../../sensorlib/rvmdk/: sensorlib.lib
  group Documentation
    ./: readme.txt
